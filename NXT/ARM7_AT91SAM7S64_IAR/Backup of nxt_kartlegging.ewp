# IAR project Backup of nxt_kartlegging.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: SAM7_IAR
  ICCARM.CCDiagSuppress: pe815, pe191, pa082, pe167
  ICCARM.CCIncludePath2: ..\source\portable\iar\AtmelSAM7S64; ..\source\include; ..\Drivere; SrcIAR; $PROJ_DIR$; ..\Includes
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: srciar\; ..\Drivere; ..\include\; ..\Source\include; ..\Source\portable\IAR\AtmelSAM7S64; ..\Includes
  OBJCOPY.OOCOutputFile: Backup of nxt_kartlegging.bin
  ILINK.IlinkOutputFile: nxt_kartlegging.out
  ILINK.IlinkIcfFile: resource\at91SAM7S64_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Bin (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  ICCARM.CCIncludePath2: ..\..\source\portable\iar\AtmelSAM7S64; ..\common\include; ..\..\source\include; SrcIAR; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: srciar\; ..\common\include; ..\..\Source\include; ..\..\Source\portable\IAR\AtmelSAM7S64
  ILINK.IlinkOutputFile: rtosdemo.out
  group Drivere
    ../Drivere/: display.c hs.c nxt_avr.c nxt_lcd.c nxt_motors.c nxt_spi.c sensors1.c sound.c twi.c
  group Includes
    ../Includes/: arq.c buffer.c calibration.c cobs.c communication.c crc.c defines.h functions.c io.c led.c mapping.c motor.c network.c nxt.c pose_controller.c pose_estimator.c sensor_tower.c simple_protocol.c
  group Scheduler Source
    ../Source/: list.c queue.c tasks.c
    ../Source/portable/IAR/AtmelSAM7S64/: port.c portasm.s79
  group Source
    ./: FreeRTOSConfig.h main.c
    ../Source/portable/MemMang/: heap_4.c
  group System Files
    SrcIAR/: Cstartup.s Cstartup_SAM7.c
